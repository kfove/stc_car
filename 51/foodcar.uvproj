# Keil uVision project foodcar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: foodcar +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c mcontrol.c mcontrol.h buzzer.c delay.c display.c seek.c uart.c uart.h ultrasound.c ultrasound.h
